# 这是一个示例 recipe 文件
# 你可以在这里添加自己的软件包定义

SUMMARY = "示例软件包"
DESCRIPTION = "这是一个自定义层的示例 recipe"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

# 示例：添加依赖
# DEPENDS = ""

# 示例：添加构建步骤
# do_compile() {
#     # 你的编译命令
# }

# 示例：添加安装步骤
# do_install() {
#     # 你的安装命令
# }

